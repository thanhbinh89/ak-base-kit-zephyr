## sources/boards/ak/ak_base_kit/board.yml
```yaml
boards:
  - name: ak_base_kit
    full_name: AK Embedded Base Kit v2.3 (STM32L151CBT6A)
    vendor: ak
    socs:
      - name: stm32l151xba
```
